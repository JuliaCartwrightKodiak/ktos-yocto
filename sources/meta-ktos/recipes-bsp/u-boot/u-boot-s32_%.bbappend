FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-ktos-disable-SAF1508-usb-phy.patch \
            "

